# Keil uVision project DIY_OSD.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8BB21F16G-QFN20 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(50000000)
  output: DIY_OSD
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group src
    ./: SILABS_STARTUP.A51
    ./src/: InitDevice.c Interrupts.c main.c spi.c
